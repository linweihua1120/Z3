# Keil uVision project Project.uvprojx, settings and files
target PY32F072xB_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: VECT_TAB_BASE=0x08000000,USE_HAL_DRIVER,PY32F072xB
  c include: ..\Inc;..\..\..\Drivers\BSP\PY32F072xx_Start_Kit;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F07X\Include;..\..\..\Drivers\PY32F07X_HAL_Driver\Inc;..\..\..\Middlewares\Third_Party\CherryUSB\port;..\..\..\Middlewares\Third_Party\CherryUSB\core;..\..\..\Middlewares\Third_Party\CherryUSB\common;..\..\..\Middlewares\Third_Party\CherryUSB\class\hid;..\..\..\..\RTT;..\sgd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xf000
  group Common
    ./: startup_py32f072xx.s
    ../Src/: system_py32f07x.c
  group Application/User
    ../Src/: main.c usbd_hid_inout_if.c app_bootloader.c app_flash.c app_i2c.c app_usart.c app_wdg.c md5.c aes.c aes.h py32f07x_hal_msp.c aesConvert.c
  group Drivers/BSP/PY32F072xx_Start_Kit
    ../../../Drivers/BSP/PY32F072xx_Start_Kit/: py32f072xx_Start_Kit.c
  group Drivers/PY32F07x_HAL_Driver
    ../../../Drivers/PY32F07x_HAL_Driver/Src/: py32f07x_hal.c py32f07x_hal_cortex.c py32f07x_hal_dma.c py32f07x_hal_gpio.c py32f07x_hal_rcc.c py32f07x_hal_rcc_ex.c py32f07x_hal_pwr.c py32f07x_hal_i2c.c py32f07x_hal_uart.c py32f07x_hal_adc.c py32f07x_hal_adc_ex.c py32f07x_hal_flash.c py32f07x_hal_tim.c py32f07x_hal_tim_ex.c py32f07x_hal_rtc.c py32f07x_hal_rtc_ex.c py32f07x_hal_can.c py32f07x_hal_comp.c
  group CherryUSB
    ../../../Middlewares/Third_Party/CherryUSB/core/: usbd_core.c
    ../../../Middlewares/Third_Party/CherryUSB/port/: usb_dc_py32.c
    ../../../Middlewares/Third_Party/CherryUSB/class/hid/: usbd_hid.c
  group Doc
    ../: readme.txt
  group RTT
    ../../../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SGD
    ../sgd/: ADC.c BatteryLed.c KTH57XXIIC.c MyI2C.c OnePluseFlash.c py32f07x_it.c sgdFlash.c sgdsb.c sb.c CurrentCtrl.c
software components: CMSIS:CORE 5.2.0
